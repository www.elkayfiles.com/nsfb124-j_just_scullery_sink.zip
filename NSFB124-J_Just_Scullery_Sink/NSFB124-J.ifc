Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-11-14T20:18:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 14 20:18:57 2023 * Host: ZILFY3SGS3 * Database: C:\Users\ENIDAM~1\AppData\Local\Temp\d574962d-15c6-4565-951d-93ce48331ef8\b639f7c1-cf85-4461-9bc8-87d2a96ba139\ifc * Database version: 5507 * Database creation date: Tue Nov 14 20:18:56 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 14 20:18:56 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 14 20:18:56 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:1/4" Head, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: NSFB124-J:NSFB124-J, NSFB124-J:NSFB124-J:811668
In: Level 1
Type - Material: Metal - Steel - Stainless - Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: NSFB124-J
Pset_DistributionFlowElementCommon - Reference: NSFB124-J; sets with these values: 2
